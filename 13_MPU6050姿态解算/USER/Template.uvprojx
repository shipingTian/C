# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10x_HD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\CORE;..\USER;..\STM32F10x_FWLIB\inc;..\SYSTEM\sys;..\SYSTEM\delay;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_tim.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/: oled.c oled.h oled_data.c oled_data.h MyI2c.c MyI2c.h serial.c serial.h MPU6050.c MPU6050.h MPU6050_Reg.h Kalman.c Kalman.h
  group README
    ../README/: redeme.txt
